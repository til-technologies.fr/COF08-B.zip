Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2018-06-11T15:23:31
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Jun 11 15:23:31 2018 * Host: B3ROBRAWR4425 * Database: C:\Users\DDA\AppData\Local\Temp\{D1C7B614-9699-4F4B-9CAB-4EB4F49FA667}\ifc * Database version: 5507 * Database creation date: Mon Jun 11 15:23:30 2018 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Mon Jun 11 15:23:30 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Jun 11 15:23:30 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, V00
LongName: V00; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level
Identity Data - Type Name: Floor Level; Building Story: yes; Name: V00; Structural: no
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm

# IfcBuildingElementProxy: COF08-B, E_Metal Case_MEPcontent_TIL Technologies_COF_FR-EN:COF08-B:1291619
In: V00
Type - Material: RAL 7045
Type - Dimensions - Depth: 436 mm; Height: 184 mm; Width: 584 mm
Type - Identity Data - Article Description: Metal case, with plastic frontal, equipped with 2 DIN rails - dim 436x584x184mm + tamper kit; Article Type: COF08-B; Content Supplier URL: www.mepcontent.com; Copyright: © Stabiplan International BV; Custom: no; Description: Metal case, with plastic frontal, equipped with 2 DIN rails - dim 436x584x184mm + tamper kit; EMCS Version: 3.0; ETIM Article Class: EC011958; Family Version: 11.15; Manufacturer: TIL Technologies; Manufacturer Art. No.: COF08-B; Manufacturer URL: http://www.til-technologies.com; MEPcontent Class: METAL_CASE; Model: COF08-B; OmniClass Number: 23.85.30.11; OmniClass Title: Access Controls; Product Line: NG series; Revit Version: 2017; Type Name: COF08-B; URL: www.stabiplan.com; Watermarked By: www.stabiplan.com
Type - Other - Category: Security Devices; Family Name: E_Metal Case_MEPcontent_TIL Technologies_COF_FR-EN
Pset_BuildingElementProxyCommon - Reference: COF08-B; IsExternal: no
Pset_ManufacturerTypeInformation - Manufacturer: TIL Technologies
Constraints - Offset: 0 mm
Dimensions - Area: 0.486778 m2; Volume: 0.045243 m3
Identity Data - Mark: 1
Other - Family: E_Metal Case_MEPcontent_TIL Technologies_COF_FR-EN: COF08-B; Family and Type: E_Metal Case_MEPcontent_TIL Technologies_COF_FR-EN: COF08-B; Type: E_Metal Case_MEPcontent_TIL Technologies_COF_FR-EN: COF08-B; Type Id: E_Metal Case_MEPcontent_TIL Technologies_COF_FR-EN: COF08-B
Phasing - Phase Created: 4. Plan over 10 years
